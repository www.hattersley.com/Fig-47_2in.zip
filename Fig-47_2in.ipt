# Autodesk Inventor part: Fig-47_2in
## iProperties
Created: 2011-03
Part Number: Fig-47_2in
Document SubType Name: Modeling
Designer: D Cole
Density: 1 g/cm^3
Author: D Cole
